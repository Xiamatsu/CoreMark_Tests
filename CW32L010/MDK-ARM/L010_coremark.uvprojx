# Keil uVision project L010_coremark.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.2
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: L010_coremark +hex
  AfterMake: fromelf --text -z -a -c --output=.\Listings\@L.lst .\Objects\@L.axf
  c flags: Optim=8 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=3
  c misc: -mcpu=cortex-m0plus+nodsp
  c include: ..\Inc;..\coremark;..\System\Core;..\System
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Main
    ../Src/: interrupts_cw32l010.c main.c
  group System
    ../System/: system_cw32l010.c startup_cw32l010.s
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
