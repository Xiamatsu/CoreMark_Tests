# IAR project L010_coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CW32L010x8 WHXY CW32L010x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\System; ..\System\Core; ..\Inc; ..\coremark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: L010_coremark.hex
  ILINK.IlinkOutputFile: L010_coremark.out
  ILINK.IlinkIcfFile: CW32L010x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
  group Main
    ../Src/: interrupts_cw32l010.c main.c
  group System
    ../System/: startup_cw32l010_iar.s system_cw32l010.c
