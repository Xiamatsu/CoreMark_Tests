# Keil uVision project F042_test2.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: STM32F042K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: F042_test1
  AfterMake: fromelf --text -z -a -c --output=.\Listings\@L.lst .\Objects\@L.axf
  c flags: Optim=8 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: STM32F042x6
  c include: ..\System\Core;..\System;..\Inc;..\coremark
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Main
    ../Src/: main.c stm32f0xx_it.c
  group System
    ../System/: startup_stm32f042.s system_stm32f0xx.c
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
target Balansed (6240000::V6.24::ARMCLANG)
  device: STM32F042K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.0.0
  cpu: as above
  output: F042_test1
  AfterMake: as above
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F042x6
  c include: ..\System\Core;..\System;..\Inc;..\coremark
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
