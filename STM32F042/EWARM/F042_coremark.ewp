# IAR project F042_coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F042K6 ST STM32F042K6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F042x6
  ICCARM.CCIncludePath2: ..\System; ..\System\Core; ..\Inc; ..\coremark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: F042_coremark.bin
  ILINK.IlinkOutputFile: F042_coremark.out
  ILINK.IlinkIcfFile: ..\System\stm32f042x6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
  group Main
    ../Src/: main.c stm32f0xx_it.c
  group System
    ../System/: startup_stm32f042_iar.s system_stm32f0xx.c
