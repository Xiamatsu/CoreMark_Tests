# IAR project F030_CoreMark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PY32F030x8 Puya PY32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: PY32F030x8
  ICCARM.CCIncludePath2: ..\Inc; ..\System; ..\System\Core; ..\coremark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: F030_CoreMark.hex
  ILINK.IlinkOutputFile: F030_CoreMark.out
  ILINK.IlinkIcfFile: F030_CoreMark.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
  group Main
    ../Src/: main.c py32f0xx_it.c
  group System
    ../System/: startup_py32f030xx_iar.s system_py32f0xx.c
