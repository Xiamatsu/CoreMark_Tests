# Keil uVision project PY088xx_Flash.uvprojx, settings and files
target PY088xx_64 (6220000::V6.22::ARMCLANG)
  device: PY32L090xC Puya
  pack: Puya.PY32L0xx_DFP.1.0.4-Beta00
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY088xx_64
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PY088xx_64,FLASH_MEM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target PY088xx_128 (6220000::V6.22::ARMCLANG)
  device: PY32L090xC Puya
  pack: Puya.PY32L0xx_DFP.1.0.4-Beta00
  cpu: as above
  output: PY088xx_128
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PY088xx_128,FLASH_MEM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY088xx_256 (6220000::V6.22::ARMCLANG)
  device: PY32L090xC Puya
  pack: Puya.PY32L0xx_DFP.1.0.4-Beta00
  cpu: as above
  output: PY088xx_256
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PY088xx_256,FLASH_MEM
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OTP (6220000::V6.22::ARMCLANG)
  device: PY32L090xC Puya
  pack: Puya.PY32L0xx_DFP.1.0.4-Beta00
  cpu: as above
  output: PY088xx_OTP
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_OTP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OB (6220000::V6.22::ARMCLANG)
  device: PY32L090xC Puya
  pack: Puya.PY32L0xx_DFP.1.0.4-Beta00
  cpu: as above
  output: PY088xx_OB
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_OB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
