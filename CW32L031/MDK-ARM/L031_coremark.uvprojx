# Keil uVision project L031_coremark.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: CW32L031F8 WHXY
  pack: WHXY.CW32L031_DFP.1.0.3
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Test1
  c flags: Optim=8 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c include: ..\System\Core;..\System;..\Inc;..\coremark
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main
    ../Src/: interrupts_cw32l031.c main.c
  group System
    ../System/: startup_cw32l031.s system_cw32l031.c
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
