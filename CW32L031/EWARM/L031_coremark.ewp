# IAR project L031_coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CW32L031F8 WHXY CW32L031F8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\System\Core; ..\System; ..\Inc; ..\coremark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: L031_coremark.bin
  ILINK.IlinkOutputFile: L031_coremark.out
  ILINK.IlinkIcfFile: C:\MCU\CW32\CW32L031\_examples\L031_coremark\System\CW32L031.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
  group Main
    ../Src/: interrupts_cw32l031.c main.c
  group System
    ../System/: startup_cw32l031_iar.s system_cw32l031.c
