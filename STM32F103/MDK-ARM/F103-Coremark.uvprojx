# Keil uVision project F103-Coremark.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test1 +hex
  AfterMake: fromelf --text -z -a -c --output=.\Listings\@L.lst .\Objects\@L.axf
  c flags: Optim=8 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: STM32F103x6
  c include: ..\System;..\System\Core;..\Inc;..\coremark
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Main
    ../Src/: main.c stm32f1xx_it.c
  group System
    ../System/: startup_stm32f103x6_keil.s system_stm32f1xx.c
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
