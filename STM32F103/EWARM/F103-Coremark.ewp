# IAR project F103-Coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C6 ST STM32F103C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103x6
  ICCARM.CCIncludePath2: ..\System; ..\System\Core; ..\Inc; ..\coremark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: F103-Coremark.bin
  ILINK.IlinkOutputFile: F103-Coremark.out
  ILINK.IlinkIcfFile: C:\MCU\STM32\stm32f103\_examples\F103-Coremark\EWARM\F103-Coremark.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
  group Main
    ../Src/: main.c stm32f1xx_it.c
  group System
    ../System/: startup_stm32f103xb_iar.s system_stm32f1xx.c
