# Keil uVision project L084_Coremark.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: HK32L088KBU6 HK_MicroChip
  pack: HKMicroChip.HK32L0xx_DFP.1.0.11
  cpu: IRAM(0x20000000,0x05000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: L084_Coremark +hex
  AfterMake: fromelf --text -z -a -c --output=.\Listings\@L.lst .\Objects\@L.axf
  c flags: Optim=8 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=2
  c include: ..\System\Core;..\System;..\Src;..\STD\inc;..\coremark
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ../Src/: hk32l0xx_it.c main.c
  group System
    ../System/: system_hk32l0xx.c startup_hk32l0xx_keil.s
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
