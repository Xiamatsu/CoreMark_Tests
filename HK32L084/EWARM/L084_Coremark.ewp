# IAR project L084_Coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HK32L084KBT6 HSXP-HK HK32L084KBT6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\System; ..\System\Core; ..\Src; ..\coremark; ..\STD\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: L084_Coremark.bin
  ILINK.IlinkOutputFile: L084_Coremark.out
  ILINK.IlinkIcfFile: HK32L0xxxB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
  group Main
    ../Src/: hk32l0xx_it.c main.c
  group System
    ../System/: startup_hk32l0xx_iar.s system_hk32l0xx.c
