# Keil uVision project E230_Coremark.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: GD32E230K8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: test1 +hex
  AfterMake: fromelf --text -z -a -c --output=.\Listings\@L.lst .\Objects\@L.axf
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c include: ..\System\Core;..\System;..\Src;..\Lib\inc;..\Coremark
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main
    ../Src/: gd32e23x_it.c main.c
  group System
    ../System/: startup_gd32e23x_keil.s system_gd32e23x.c
  group Firmware
    ../Lib/src/: gd32e23x_misc.c gd32e23x_syscfg.c gd32e23x_rcu.c gd32e23x_gpio.c
    ../../test1/Lib/src/: gd32e23x_usart.c
  group Coremark
    ../Coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
