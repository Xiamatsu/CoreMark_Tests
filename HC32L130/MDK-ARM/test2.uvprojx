# Keil uVision project test2.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: HC32L130E8PA HDSC
  pack: HDSC.HC32L130.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: test1 +hex
  AfterMake: fromelf --text -z -a -c --output=.\Listings\@L.lst .\Objects\@L.axf
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\System;..\System\Core;..\Inc;..\driver\inc;..\coremark
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main
    ../Src/: interrupts_hc32l13x.c main.c
  group System
    ../System/: startup_hc32l13x.s system_hc32l13x.c
  group Firmware
    ../driver/src/: sysctrl.c ddl.c flash.c gpio.c
    ../../test1/driver/src/: uart.c
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
