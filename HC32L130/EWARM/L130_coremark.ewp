# IAR project L130_coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L130x8 XHSC HC32L130x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Inc; ..\System; ..\System\Core; ..\driver\inc; ..\coremark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: L130_coremark.bin
  ILINK.IlinkOutputFile: L130_coremark.out
  ILINK.IlinkIcfFile: L130_coremark.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
  group Firmware
    ../driver/src/: ddl.c flash.c gpio.c sysctrl.c uart.c
  group Main
    ../Src/: interrupts_hc32l13x.c main.c
  group System
    ../System/: startup_hc32l13x_iar.s system_hc32l13x.c
