# IAR project Coremark_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G430x8 Nations N32G430x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __FPU_PRESENT; N32G430
  ICCARM.CCIncludePath2: ..\inc; ..\coremark; ..\System; ..\System\Core; ..\firmware\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Coremark_test.bin
  ILINK.IlinkOutputFile: Coremark_test.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
  group Firmware
    ../firmware/src/: misc.c n32g430_flash.c n32g430_gpio.c n32g430_rcc.c n32g430_usart.c
  group Main
    ../src/: main.c n32g430_it.c
  group System
    ../System/: startup_n32g430_iar.s system_n32g430.c
