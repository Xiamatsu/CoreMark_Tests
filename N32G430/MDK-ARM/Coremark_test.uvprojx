# Keil uVision project Coremark_test.uvprojx, settings and files
target N32G430 (6240000::V6.24::ARMCLANG)
  device: N32G430F8S7 NSING
  pack: NSING.N32G430_DFP.1.1.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Coremark_test
  AfterMake: fromelf --text -z -a -c --output=.\Listings\@L.lst .\Objects\@L.axf
  c flags: Optim=8 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=2
  c misc: -Wno-unused-parameter
  c include: ..\inc;..\coremark;..\System;..\System\Core;..\firmware\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Main
    ../src/: main.c n32g430_it.c
  group System
    ../System/: system_n32g430.c startup_n32g430_keil.s
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
  group Firmware
    ../firmware/src/: misc.c n32g430_flash.c n32g430_gpio.c n32g430_rcc.c n32g430_usart.c
