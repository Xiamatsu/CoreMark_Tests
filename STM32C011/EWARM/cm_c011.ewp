# IAR project cm_c011.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32C011F6 ST STM32C011F6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32C011xx
  ICCARM.CCIncludePath2: ..\Inc; ..\System; ..\coremark; ..\System\Core
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cm_c011.bin
  ILINK.IlinkOutputFile: cm_c011.out
  ILINK.IlinkIcfFile: stm32c011xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group CoreMark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
  group Main
    ../Src/: main.c stm32c0xx_it.c
  group System
    ./: startup_stm32c011xx.s
    ../System/: system_stm32c0xx.c
