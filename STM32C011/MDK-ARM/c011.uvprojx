# Keil uVision project c011.uvprojx, settings and files
target C011 (6240000::V6.24::ARMCLANG)
  device: STM32C011F6Px STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: c011
  AfterMake: fromelf --text -z -a -c --output=.\Listings\@L.lst .\Objects\@L.axf
  c flags: Optim=8 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=2
  c define: STM32C011xx
  c include: ..\Inc;..\System;..\coremark;..\System\Core
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Main
    ../Src/: main.c stm32c0xx_it.c
  group System
    ../System/: startup_stm32c011xx.s system_stm32c0xx.c
  group CoreMark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
