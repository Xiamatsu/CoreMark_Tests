# Keil uVision project L406_coremark.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: N32L406CB NSING
  pack: NSING.N32L40x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: L406_coremark +hex
  AfterMake: fromelf --text -z -a -c --output=.\Listings\@L.lst .\Objects\@L.axf
  AfterMake: fromelf --bin --output=.\bin\@L.bin .\Objects\@L.axf
  c flags: Optim=8 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=2
  c define: N32L406CB,__FPU_PRESENT,USE_STDPERIPH_DRIVER
  c include: ..\System;..\System\core;..\Inc;..\n32l40x_std\inc;..\coremark
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Main
    ../Src/: main.c n32l40x_it.c
  group System
    ../System/: startup_n32l40x.s system_n32l40x.c
  group CoreMark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
  group Firmware
    ../n32l40x_std/src/: misc.c n32l40x_flash.c n32l40x_gpio.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_usart.c
