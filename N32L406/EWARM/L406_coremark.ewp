# IAR project L406_coremark.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32L406xB Nations N32L406xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32L406CB; __FPU_PRESENT; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\System; ..\System\core; ..\n32l40x_std\inc; ..\coremark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: L406_coremark.hex
  ILINK.IlinkOutputFile: L406_coremark.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Coremark
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c cvt.c ee_printf.c
  group Firmware
    ../n32l40x_std/src/: misc.c n32l40x_flash.c n32l40x_gpio.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_usart.c
  group Main
    ../Src/: main.c n32l40x_it.c
  group System
    ../System/: startup_n32l40x_EWARM.s system_n32l40x.c
